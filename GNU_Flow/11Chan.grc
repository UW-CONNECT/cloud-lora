options:
  parameters:
    author: Patron
    generate_options: qt_gui
    id: chan_11
    output_language: python
    title: ID
  states: {}

blocks:
- name: FBtaps
  id: variable
  parameters:
    value: '[1, -3.74412117687482, 5.30709175926160, -3.37351017499529, 0.811127773099310]'
  states: {}
- name: FFtaps
  id: variable
  parameters:
    value: '[8.98440657102068e-05, 9.54644212279418e-05, 0.000153599440344735, 9.54644212279418e-05, 8.98440657102070e-05]'
  states: {}
- name: M_PI
  id: variable
  parameters:
    value: '3.14159265358979323846'
  states: {}
- name: dec_factor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/uwcon/Desktop/RL_Data/Quick_Tests/7chan_2M
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-1 * M_PI) / 5
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (1 * M_PI) / 5
  states: {}
- name: blocks_rotator_cc_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (2 * M_PI) / 5
  states: {}
- name: blocks_rotator_cc_0_0_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-2 * M_PI) / 5
  states: {}
- name: blocks_rotator_cc_0_0_0_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: (4 * M_PI) / 5
  states: {state: disabled}
- name: blocks_rotator_cc_0_0_0_1_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-3 * M_PI) / 5
  states: {}
- name: blocks_rotator_cc_0_0_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: (3 * M_PI) / 5
  states: {}
- name: blocks_rotator_cc_0_0_1_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (-4 * M_PI) / 5
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_1_1
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {state: disabled}
- name: iir_filter_xxx_0_0_1_1_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_2
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {}
- name: iir_filter_xxx_0_0_2_0
  id: iir_filter_xxx
  parameters:
    fbtaps: FBtaps
    fftaps: FFtaps
    oldstyle: 'False'
    type: ccd
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2000'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5200'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2010'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '1998'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2020'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '2030'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: network_udp_sink_0_0_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5100'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_1_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '5000'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_0_0_1_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '32768'
    port: '4900'
    send_eof: 'False'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0_2
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_3
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_4
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_5
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_6
  id: rational_resampler_xxx
  parameters:
    decim: dec_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: 903.3e6
    dev_args: '""'
    gain0: '0'
    samp_rate: samp_rate
    start_time: '-1'
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_rotator_cc_0, '0', iir_filter_xxx_0_0_0, '0']
- [blocks_rotator_cc_0_0, '0', iir_filter_xxx_0_0, '0']
- [blocks_rotator_cc_0_0_0, '0', iir_filter_xxx_0_0_1, '0']
- [blocks_rotator_cc_0_0_0_0, '0', iir_filter_xxx_0_0_1_0, '0']
- [blocks_rotator_cc_0_0_0_1, '0', iir_filter_xxx_0_0_1_1, '0']
- [blocks_rotator_cc_0_0_0_1_0, '0', iir_filter_xxx_0_0_1_1_0, '0']
- [blocks_rotator_cc_0_0_1, '0', iir_filter_xxx_0_0_2, '0']
- [blocks_rotator_cc_0_0_1_0, '0', iir_filter_xxx_0_0_2_0, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_0, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_0_0_0_1_0, '0']
- [blocks_throttle_0, '0', blocks_rotator_cc_0_0_1, '0']
- [blocks_throttle_0, '0', iir_filter_xxx_0, '0']
- [iir_filter_xxx_0, '0', rational_resampler_xxx_0_0_0_2, '0']
- [iir_filter_xxx_0_0, '0', rational_resampler_xxx_0_0_0_3, '0']
- [iir_filter_xxx_0_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [iir_filter_xxx_0_0_1, '0', rational_resampler_xxx_0_0_0_4, '0']
- [iir_filter_xxx_0_0_1_0, '0', rational_resampler_xxx_0_0_0, '0']
- [iir_filter_xxx_0_0_1_1, '0', rational_resampler_xxx_0_0_0_6, '0']
- [iir_filter_xxx_0_0_1_1_0, '0', rational_resampler_xxx_0_0, '0']
- [iir_filter_xxx_0_0_2, '0', rational_resampler_xxx_0_0_0_5, '0']
- [iir_filter_xxx_0_0_2_0, '0', rational_resampler_xxx_0_0_0_1, '0']
- [rational_resampler_xxx_0_0, '0', network_udp_sink_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_sink_x_0_0_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0, '0', network_udp_sink_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_sink_x_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', network_udp_sink_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', qtgui_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0_0_1, '0', network_udp_sink_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_1, '0', qtgui_sink_x_0_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0_2, '0', network_udp_sink_0, '0']
- [rational_resampler_xxx_0_0_0_2, '0', qtgui_sink_x_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_3, '0', network_udp_sink_0_0, '0']
- [rational_resampler_xxx_0_0_0_3, '0', qtgui_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_4, '0', network_udp_sink_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_4, '0', qtgui_sink_x_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_5, '0', network_udp_sink_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0_5, '0', qtgui_sink_x_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_6, '0', network_udp_sink_0_0_1_0_0, '0']
- [rational_resampler_xxx_0_0_0_6, '0', qtgui_sink_x_0_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0_0_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0_1_0, '0']
- [uhd_usrp_source_0, '0', iir_filter_xxx_0, '0']

metadata:
  file_format: 1
